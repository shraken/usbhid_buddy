# Keil uVision project daq_buddy.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F380 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: daq_buddy +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: C8051. NDEBUG
  c include: ..\code\include;..\code\A51;..\code\source;..\code\source\drivers;..\..\lib\libbuddy;C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base
  asm include: ..\code\include
  group ASM
    ../code/A51/: STARTUP.A51 FIFO_RD_XD.a51 FIFO_WT_XD.a51
  group Main
    ../code/source/: action.c adc.c F3xx_USB0_Descriptor.c F3xx_USB0_InterruptServiceRoutine.c F3xx_USB0_ReportHandler.c F3xx_USB0_Standard_Requests.c gpio.c init.c main.c spi.c support.c timers.c uart.c
  group Drivers
    ../code/source/drivers/: tlv563x.c
