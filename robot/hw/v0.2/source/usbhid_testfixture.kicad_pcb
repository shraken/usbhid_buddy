# Repository shraken/usbhid_buddy

File README.md:

# Buddy DAQ

Buddy is a free, open source, and low-cost data acquisition (DAQ) instrument.  It has 8 configurable
IO that can be configured for ADC, DAC, PWM, or counter operation.  The device uses USB HID with a 
custom descriptor for communication with the hidapi library on the host system.  The device can be 
configured as either a host polled or asynchronous update mode for maximum flexibility.  Buddy works
on linux, windows, and macOS systems.  

## Docker

Usage of docker is recommended for building the entire project.  A CMakeList file is provided in the head
directory to build the project and generate all support files (documentation, coverage reports). 

```shell
docker build -t buddy_docker .
docker run -v /path/to/usbhid_buddy:/docker -it buddy_docker /bin/bash
```

this will launch a Docker bash shell and then you build.

```shell
cd /docker
mkdir -p build
cd build
cmake ..
make
```

## Firmware

The firmware is written in C for the Silicon Labs C8051F380/EFM8UB2 chip and is in the `fw` directory.  The
firmware requires a Keil C51 compiler to be used for building.  

The open-source [gboot](https://github.com/shraken/gboot) bootloader written by Gabriele Gorla of gglabs (http://gglabs.us) is used for the buddy device. 

## Hardware

The hardware is developed using the KiCad EDA tool.  The manafacturing, source, and schematic
files are provided in the hw/ directory.

The pin mapping for the standard Bus Pirate 10-pin harness is provided below:

| Color         | Mapping   | Pin #  |
| ------------- |:---------:|:------:|
| Brown         | IN7       |     2  |
| Red           | GND       |     1  |
| Orange        | IN6       |     4  |
| Yellow        | IN5       |     3  |
| Green         | IN0       |     6  |
| Blue          | IN4       |     5  |
| Purple        | IN2       |     8  |
| Grey          | IN1       |     7  |
| White         | 3.3V      |    10  |
| Black         | IN3       |     9  |

## Software

The host software uses the free and open source hidapi library for driverless
operation.  The examples provided build with the hidapi libray itself and
are tested on Linux, Windows, and mac OS systems.

For building the host examples, the hidapi submodule must be cloned with the
following command:

`git submodule update --init`

or when cloning the buddy repo with:

`git clone --recursive https://github.com/shraken/usbhid_buddy.git`

## Tests

The `tests` directory contains the unit tests.  The [Catch2](https://github.com/catchorg/Catch2) test
framework is used for all unit tests.  To manually build and run the unit test, run the following:

```shell
cd tests/
mkdir -p build
cd build
cmake ..
make
./testLibBuddy
```

## Code Coverage

The build server runs gcov/lcov to generate the coverage figure.  You can collect these results manually
by running the following (from the build directory in `tests`):

```shell
lcov -c -d CMakeFiles -out cov.info
genhtml cov.info -o out
open out/index.html
```

## KiCad design robot/hw/v0.2/source/usbhid_testfixture.kicad_pcb

File robot/README.md:

# Buddy Test Platform

This repo contains the manufacturing automated test system for the Buddy USB HID DAQ hardware
device.  

The automated test board mates with a Teensy 3.6 microcontroller for measurement and
stimulus of the "Buddy" DAQ under test.
 - `teensy/` - teensy Arduino firmware for the DUT test software
 - `sw/` - host based robot framework source files to be run by tester
 - `hw/` - PCB schematic, layout, and datasheet files

# Requirements

Install the [ADC](https://github.com/pedvide/ADC) library for the Arduino software.  

# Building

There is no automated build procedure.  

1. Open Arduino IDE 

Modify the `RingBuffer.h` file and set the define `RING_BUFFER_DEFAULT_BUFFER_SIZE` to 4096.  This
requires modification of the `RingBuffer.h` file provided in the `ADC` library installed above.  

# Usage

on Windows

```shell
cd sw/
./run_tests.bat
```

on Linux and Mac OS

```shell
cd sw/
./run_tests.sh
```

Board: 4 copper layers, 108.5 x 38.5 mm, 45 parts (8 on the bottom side), 51 nets.

Parts:
C1, C2, C3: 0.1uF; C_0603_HandSoldering
D1, D2: LED; LED_0603_HandSoldering
J1, J2: Conn_01x24; Pin_Header_Straight_1x24_Pitch2.54mm
J3, J5, J6, J7, J8, J9, J10, J11: TEST_1P; Measurement_Point_Round-TH_Big
J4: Conn_02x05_Odd_Even; Socket_Strip_Straight_2x05_Pitch2.54mm
P1: BTE-020-01-F-D; BTE-020-01-F-D-A
R1, R2, R3, R4, R5, R8, R9, R10, R11, R16, R17, R18, R19: 10k; R_0603_HandSoldering
R6, R7: 1k; R_0603_HandSoldering
R12, R13, R14, R15, R20, R21, R22, R23: 5.1k; R_0603_HandSoldering
U1, U2: MAX335; TSSOP-24_4.4x7.8mm_Pitch0.65mm
U3, U4: 74AHC1G125; SOT-23-5
U5: MAX4617; TSSOP-16_4.4x5mm_Pitch0.65mm

Connections:
+3V3: J1.15, J2.22, J11.1, R1.2, R2.2, R3.1, R4.1, R6.2, R7.2, U3.5, U4.5
/actives/ADC_0: J2.12, R8.1, R12.2
/actives/ADC_0_F: R12.1, U2.5
/actives/ADC_1: J2.13, R9.1, R13.2
/actives/ADC_1_F: R13.1, U2.7
/actives/ADC_2: J2.14, R10.1, R14.2
/actives/ADC_2_F: R14.1, U2.9
/actives/ADC_3: J2.15, R11.1, R15.2
/actives/ADC_3_F: R15.1, U2.11
/actives/ADC_4: J2.16, R16.1, R20.2
/actives/ADC_4_F: R20.1, U2.14
/actives/ADC_5: J2.17, R17.1, R21.2
/actives/ADC_5_F: R21.1, U2.16
/actives/ADC_6: J2.18, R18.1, R22.2
/actives/ADC_6_F: R22.1, U2.18
/actives/ADC_7: J2.19, R19.1, R23.2
/actives/ADC_7_F: R23.1, U2.20
/actives/DAC: J2.8, U5.3
/actives/DAC_MUX_EN: J1.19, R5.1, U5.6
/actives/DAC_MUX_SEL_A: J1.16, U5.11
/actives/DAC_MUX_SEL_B: J1.17, U5.10
/actives/DAC_MUX_SEL_C: J1.18, U5.9
/actives/FIO_0: J4.6, P1.1, U1.6, U2.6, U5.13
/actives/FIO_1: J4.7, P1.5, U1.8, U2.8, U5.14
/actives/FIO_2: J4.8, P1.9, U1.10, U2.10, U5.15
/actives/FIO_3: J4.9, P1.13, U1.12, U2.12, U5.12
/actives/FIO_4: J4.5, P1.14, U1.13, U2.13, U5.1
/actives/FIO_5: J4.3, P1.10, U1.15, U2.15, U5.5
/actives/FIO_6: J4.4, P1.6, U1.17, U2.17, U5.2
/actives/FIO_7: J4.2, P1.2, U1.19, U2.19, U5.4
/actives/PWM_0: J1.4, U1.5
/actives/PWM_1: J1.5, U1.7
/actives/PWM_2: J1.6, U1.9
/actives/PWM_3: J1.7, U1.11
/actives/PWM_4: J1.8, U1.14
/actives/PWM_5: J1.9, U1.16
/actives/PWM_6: J1.10, U1.18
/actives/PWM_7: J1.11, U1.20
/actives/SPI_CS0: J1.12, J3.1, R1.1, R3.2, U1.24, U3.1
/actives/SPI_CS1: J1.23, J5.1, R2.1, R4.2, U2.24, U4.1
/actives/SPI_DIN: J1.13, J7.1, U1.3, U2.3
/actives/SPI_DOUT: J1.14, J8.1, U3.4, U4.4
/actives/SPI_SCLK: J2.11, J6.1, U1.1, U2.1
/connectors/TEENSY_38: D2.1, J2.6
/connectors/TEENSY_39: D1.1, J2.7
GND: C1.1, C2.1, C3.1, J1.1, J2.10, J2.23, J4.1, J9.1, P1.3, P1.4, P1.7, P1.8, P1.11, P1.12, P1.15, P1.16, P1.33, P1.34, P1.35, P1.36, R5.2, R8.2, R9.2, R10.2, R11.2, R16.2, R17.2, R18.2, R19.2, U1.4, U1.21, U2.4, U2.21, U3.3, U4.3, U5.8
unnamed: D1.2, R6.1
unnamed: D2.2, R7.1
unnamed: U1.22, U3.2
unnamed: U2.22, U4.2
VCC: C1.2, C2.2, C3.2, J2.24, J4.10, J10.1, U1.2, U1.23, U2.2, U2.23, U5.16

## KiCad design hw/v0.1/source/usbhid_daq.kicad_pcb

Board: 4 copper layers, 40.4 x 42.5 mm, 39 parts (3 on the bottom side), 42 nets.

Parts:
C1, C6, C7, C13: 100nF; C_0603_HandSoldering
C2, C4, C5, C9: 1uF; C_0805_HandSoldering
C3: C3; C_0603_HandSoldering
C8, C14: 1uF; C_0603_HandSoldering
D1: PRTR5V0U2X,215
DN1: LTST-C195KGJRKT
M1, M2, M3, M4: MountingHole_2.7mm_M2.5_Pad
P1: CONN_01X02; Socket_Strip_Straight_1x02
P2: CONN_01X03; Socket_Strip_Straight_1x03
P4, P5: CONN_01X09; Pin_Header_Straight_1x09
P6: CONN_02X05; Socket_Strip_Angled_2x05
R1: 100R; R_0603_HandSoldering
R2, R3, R8, R9: 1k; R_0603_HandSoldering
R4, R11: 0R; R_0603_HandSoldering
R7, R10, R12: 10k; R_0603_HandSoldering
SW1: SKRKAEE010
U1: MCP1802T-3302I/OT; SOT-23-5
U2: C8051F380; LQFP-48_7x7mm_Pitch0.5mm
U3: TLV5630; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U4: TPS60241; VSSOP8-DGK
U5: REF3325AIDBZR; SOT-23
USB1: ZX62R-B-5P; microb_usb

Connections:
+3V3: C3.1, C8.1, P6.2, R7.1, R10.1, R12.2, U1.5, U3.5, U3.17, U3.20
+5V: C7.1, C9.1, U3.11, U4.1
/mcu/ADC0_IN: P5.2, U2.38
/mcu/ADC1_IN: P5.3, U2.37
/mcu/ADC2_IN: P5.4, U2.36
/mcu/ADC3_IN: P5.5, U2.35
/mcu/ADC4_IN: P5.6, U2.34
/mcu/ADC5_IN: P5.7, U2.33
/mcu/ADC6_IN: P5.8, U2.32
/mcu/ADC7_IN: P5.9, U2.31
/mcu/C2CK: P2.1, R2.2, R12.1, U2.13
/mcu/C2D: P2.2, U2.14
/mcu/MCU_LDAC: R4.1, R11.2, U2.39, U3.18
/mcu/SPI_CS: U2.43, U3.4
/mcu/SPI_MOSI: R7.2, U2.44, U3.2
/mcu/SPI_SCLK: R10.2, U2.46, U3.3
/mcu/UART_RX: P1.2, U2.1
/mcu/UART_TX: P1.1, U2.2
/mcu/USBDN: D1.3, U2.9, USB1.4
/mcu/USBDP: D1.2, U2.8, USB1.3
/periph/DAC_OUTA: P4.2, P6.8, U3.12
/periph/DAC_OUTB: P4.3, P6.6, U3.13
/periph/DAC_OUTC: P4.4, P6.4, U3.14
/periph/DAC_OUTD: P4.5, P6.9, U3.15
/periph/DAC_OUTE: P4.6, P6.7, U3.6
/periph/DAC_OUTF: P4.7, P6.5, U3.7
/periph/DAC_OUTG: P4.8, P6.3, U3.8
/periph/DAC_OUTH: P4.9, P6.1, U3.9
/periph/DAC_REF_V2_5: C13.1, C14.1, U3.16, U5.2
GND: C1.2, C2.2, C3.2, C6.2, C7.2, C8.2, C9.2, C13.2, C14.2, D1.1, M1.1, M2.1, M3.1, M4.1, P2.3, P4.1, P5.1, P6.10, R1.2, R4.2, R8.1, R9.1, R11.1, SW1.2, U1.2, U2.7, U3.1, U3.10, U4.4, U5.3, USB1.0, USB1.1
unnamed: C4.1, U4.7
unnamed: C4.2, U4.5
unnamed: C5.1, U4.8
unnamed: C5.2, U4.3
unnamed: C6.1, R2.1, R3.2, SW1.1
unnamed: DN1.1, U2.40
unnamed: DN1.2, U2.41
unnamed: DN1.3, R9.2
unnamed: DN1.4, R8.2
unnamed: R1.1, U2.12
VBUS: C1.1, C2.1, D1.4, U1.1, U1.3, U2.11, U4.2, U4.6, U5.1, USB1.5
VMCU_3V3: R3.1, U2.10

## KiCad design hw/v0.4/source/usbhid_daq.kicad_pcb

Parts:
R7, R10: 10k; R_0603_HandSoldering
R11: 0R_NM; R_0603_HandSoldering

Connections:
+3V3: R7.1, R10.1; also elsewhere on the board
/mcu/MCU_LDAC: R11.2; also elsewhere on the board
/mcu/SPI_MOSI: R7.2; also elsewhere on the board
/mcu/SPI_SCLK: R10.2; also elsewhere on the board
GND: R11.1; also elsewhere on the board

Parts:
C1, C3, C6: 100nF; C_0603_HandSoldering
C10: 4.7uF; C_0603_HandSoldering
C11: 0.1uF; C_0603_HandSoldering
D1, D2: LED; LED_0603
D3: PRTR5V0U2X,215
D4, D5, D6, D7, D8, D9, D10, D11: D_Schottky_x2_Serial_AKC; SOT-23
DN1: LTST-C195KGJRKT
F1: 1206L050/15YR; R_1206
P1: CONN_01X02; Socket_Strip_Straight_1x02
P2: CONN_01X03; Socket_Strip_Straight_1x03
P3: CONN_01X03; Molex_PicoBlade_53261-0371
R1: 100R; R_0603_HandSoldering
R2, R3, R5, R8, R9, R14: 1k; R_0603_HandSoldering
R4, R12, R13: 0R; R_0603_HandSoldering
R6: 10k; R_0603_HandSoldering
SW1, SW2: SKRKAEE010
U1: MCP1802T-3302I/OT; SOT-23-5
U2: C8051F380; LQFP-48_7x7mm_Pitch0.5mm
USB1: MICRO-B_USB; microb_usb_top_mount
W1: TEST_1P; TESTPAD_SMALL

Connections:
+3V3: C3.1, D4.2 (K), D5.2 (K), D6.2 (K), D7.2 (K), D8.2 (K), D9.2 (K), D10.2 (K), D11.2 (K), R3.1, R6.1, R8.1, R9.1, R14.1, U1.5 (VOUT), W1.1; also elsewhere on the board
/mcu/ADC0_IN: D4.3 (common), R12.2, U2.38 (P2.0); also elsewhere on the board
/mcu/ADC1_IN: D9.3 (common), R13.2, U2.37 (P2.1); also elsewhere on the board
/mcu/ADC2_IN: D8.3 (common), U2.36 (P2.2); also elsewhere on the board
/mcu/ADC3_IN: D5.3 (common), U2.35 (P2.3); also elsewhere on the board
/mcu/ADC4_IN: D6.3 (common), U2.34 (P2.4); also elsewhere on the board
/mcu/ADC5_IN: D10.3 (common), U2.33 (P2.5); also elsewhere on the board
/mcu/ADC6_IN: D11.3 (common), U2.32 (P2.6); also elsewhere on the board
/mcu/ADC7_IN: D7.3 (common), U2.31 (P2.7); also elsewhere on the board
/mcu/C2CK: P2.1, P3.1, R2.2, U2.13 (RST/C2CK)
/mcu/C2D: P2.2, P3.2, U2.14 (C2D)
/mcu/MCU_LDAC: U2.39 (P1.7); also elsewhere on the board
/mcu/REF_V2_5: R4.1; also elsewhere on the board
/mcu/SPI_MISO: U2.45 (P1.1); also elsewhere on the board
/mcu/SPI_MOSI: U2.44 (P1.2); also elsewhere on the board
/mcu/SPI_SCLK: U2.46 (P1.0); also elsewhere on the board
/mcu/UART_RX: P1.2, U2.1 (P0.5)
/mcu/UART_TX: P1.1, U2.2 (P0.4)
/mcu/USBDN: D3.2, U2.9 (D-), USB1.2
/mcu/USBDP: D3.3, U2.8 (D+), USB1.3
/periph/SPI_CS_DAC: U2.43 (P1.3); also elsewhere on the board
/periph/SPI_CS_MEM: U2.42 (P1.4); also elsewhere on the board
GND: C1.2, C3.2, C6.2, C10.1, C11.1, D3.1, D4.1 (A), D5.1 (A), D6.1 (A), D7.1 (A), D8.1 (A), D9.1 (A), D10.1 (A), D11.1 (A), P2.3, P3.3, R5.2, SW1.2, SW2.2, U1.2 (VSS), U2.7 (GND), USB1.5; also elsewhere on the board
unnamed: C6.1, R2.1, R3.2, SW1.1
unnamed: C10.2, C11.2, R4.2, U2.41 (P1.5)
unnamed: D1.1 (K), U2.15 (P4.7)
unnamed: D1.2 (A), R14.2
unnamed: D2.1 (K), R5.1
unnamed: DN1.1 (GA), R8.2
unnamed: DN1.2 (RA), R9.2
unnamed: DN1.3 (GC), U2.25 (P3.5)
unnamed: DN1.4 (RC), U2.26 (P3.4)
unnamed: R1.1, U2.12 (VBUS)
unnamed: R6.2, SW2.1, U2.24 (P3.6)
unnamed: R12.1, U2.5 (P0.1)
unnamed: R13.1, U2.6 (P0.0)
VBUS: C1.1, D2.2 (A), F1.2, R1.2, U1.1 (VIN), U1.3 (SHDN), U2.11 (REGIN); also elsewhere on the board
VBUS_PRI: D3.4, F1.1, USB1.1
VMCU_3V3: U2.10 (VDD)

Notes on the sheet:
Short R12 and R13 to enable ADC0_IN and ADC1_IN as pin interrupt pins

Parts:
C2, C4, C5, C9: 1uF; C_0805_HandSoldering
C7, C12, C13: 100nF; C_0603_HandSoldering
C8, C14: 1uF; C_0603_HandSoldering
C15: 10uF; C_0603_HandSoldering
C16: 0.1uF; C_0603_HandSoldering
P4: CONN_02X05; Socket_Strip_Angled_2x05
R15, R16, R17: 10k; R_0603_HandSoldering
U3: TLV5630; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U4: TPS60241; VSSOP8-DGK
U5: REF3325AIDBZR; SOT-23
U6: 23LC1024-I/ST; TSSOP-8_4.4x3mm_Pitch0.65mm
U7, U8: 74AHC1G125; SOT-353_SC-70-5_Handsoldering
W3, W4, W5, W6, W7, W8, W9: TEST_1P; TESTPAD_SMALL

Connections:
+3V3: C8.1, C12.2, P4.10, R15.1, R16.1, R17.1, U3.5 (~PRE), U3.17 (MODE), U3.20 (DVDD), U6.8 (VCC), U7.5, U8.5; also elsewhere on the board
+5V: C7.1, C9.1, U3.11 (AVDD), U4.1 (VOUT), W9.1
/mcu/ADC0_IN: P4.6, U3.12 (OUTA); also elsewhere on the board
/mcu/ADC1_IN: P4.7, U3.13 (OUTB); also elsewhere on the board
/mcu/ADC2_IN: P4.8, U3.14 (OUTC); also elsewhere on the board
/mcu/ADC3_IN: P4.9, U3.15 (OUTD); also elsewhere on the board
/mcu/ADC4_IN: P4.5, U3.6 (OUTE); also elsewhere on the board
/mcu/ADC5_IN: P4.3, U3.7 (OUTF); also elsewhere on the board
/mcu/ADC6_IN: P4.4, U3.8 (OUTG); also elsewhere on the board
/mcu/ADC7_IN: P4.2, U3.9 (OUTH); also elsewhere on the board
/mcu/MCU_LDAC: U3.18 (~LDAC); also elsewhere on the board
/mcu/REF_V2_5: C13.1, C14.1, C15.1, C16.1, U3.16 (REF), U5.2 (OUT), W8.1; also elsewhere on the board
/mcu/SPI_MISO: U7.4, U8.4, W5.1; also elsewhere on the board
/mcu/SPI_MOSI: U3.2 (DIN), U6.5 (SI/SIO0), W4.1; also elsewhere on the board
/mcu/SPI_SCLK: U3.3 (SCLK), U6.6 (SCK), W3.1; also elsewhere on the board
/periph/SPI_CS_DAC: R17.2, U3.4 (FS), U8.1, W6.1; also elsewhere on the board
/periph/SPI_CS_MEM: R15.2, U6.1 (CS), U7.1, W7.1; also elsewhere on the board
GND: C2.2, C7.2, C8.2, C9.2, C12.1, C13.2, C14.2, C15.2, C16.2, P4.1, U3.1 (DGND), U3.10 (AGND), U4.4 (GND), U5.3 (GND), U6.4 (VSS), U7.3, U8.3; also elsewhere on the board
unnamed: C4.1, U4.7 (C1+)
unnamed: C4.2, U4.5 (C1-)
unnamed: C5.1, U4.8 (C2+)
unnamed: C5.2, U4.3 (C2-)
unnamed: R16.2, U6.7 (HOLD/SIO3)
unnamed: U3.19 (DOUT), U8.2
unnamed: U6.2 (SO/SIO1), U7.2
VBUS: C2.1, U4.2 (EN), U4.6 (VIN), U5.1 (IN); also elsewhere on the board

Board: 4 copper layers, 63.9 x 37.1 mm, 69 parts (12 on the bottom side), 46 nets.

File hw/BOM.xlsx:

Id | Designator | Package | Quantity | Designation | Supplier and ref | Cost (quantity 1) | Total Cost | Comments
1 | R5,R2,R8,R9,R3,R14 | R_0603_HandSoldering | 6 | 1k | 667-ERJ-3EKF1001V | 0.15 | 0.89999999999999991
2 | C1,C3,C6,C7,C10,C11,C12,C13,C16 | C_0603_HandSoldering | 9 | 100nF | 81-GRM39X104K25 | 0.1 | 0.9
3 | C2,C4,C5,C9 | C_0805_HandSoldering | 4 | 1uF | 810-C2012X7R1E105K | 0.14000000000000001 | 0.56000000000000005
4 | C8,C14 | C_0603_HandSoldering | 2 | 1uF | 81-GRM188R61E105KA12 | 0.1 | 0.2
5 | C15 | C_0603_HandSoldering | 1 | 10uF | 81-GRM188R60J106KE7D | 0.13 | 0.13
6 | C10 | C_0603_HandSoldering | 1 | 4.7uF | 81-GRM18R60J475KE19D | 0.11 | 0.11
7 | R1 | R_0603_HandSoldering | 1 | 100R | 660-RK73H1JTTD1000F | 0.1 | 0.1
8 | R2,R3,R5,R8,R9,R14 | R_0603_HandSoldering | 6 | 1k | 667-ERJ-3GEYJ102V | 0.1 | 0.60000000000000009
9 | R6,R7,R10,R15,R16,R17 | R_0603_HandSoldering | 6 | 10k | 667-ERJ-3GEYJ103V | 0.1 | 0.60000000000000009
10 | R11 | R_0603_HandSoldering | 1 | 0R_NM | 667-ERJ-3GEY0R00V |  | 0 | NM
11 | R4,R12,R13 | R_0603_HandSoldering | 3 | 0R | 667-ERJ-3GEY0R00V | 0.1 | 0.30000000000000004
12 | D1,D2 | LED_0603 | 2 | LED | 720-LGQ396A3964 | 0.19 | 0.38
13 | D3 | PRTR5V0U2X,215 | 1 | PRTR5V0U2X,215 | 771-PRTR5V0U2X-T/R | 0.52 | 0.52
14 | D4,D5,D6,D7,D8,D9,D10,D11 | SOT-23 | 8 | D_Schottky_x2_Serial_AKC | 512-BAT54S | 0.24 | 1.92
15 | DN1 | LTST-C195KGJRKT | 1 | LTST-C195KGJRKT | 859-LTST-C195KGJRKT | 0.4 | 0.4
16 | F1 | R_1206 | 1 | 1206L050/15YR | 576-1206L075/13.2WR | 0.49 | 0.49
17 | U1 | SOT-23-5 | 1 | MCP1802T-3302I/OT | 579-MCP1802T-3302IOT | 0.57999999999999996 | 0.57999999999999996
18 | U2 | LQFP-48_7x7mm_Pitch0.5mm | 1 | C8051F380 | 634-8UB20F64GAQFP48 | 1.9 | 1.9
19 | U3 | TSSOP-20_4.4x6.5mm_Pitch0.65mm | 1 | TLV5630 | 595-TLV5630IPW | 20.12 | 20.12
20 | U4 | VSSOP8-DGK | 1 | TPS60241 | 595-TPS60241DGKR | 1.63 | 1.63
21 | U5 | SOT-23 | 1 | REF3325AIDBZR | 595-REF3325AIDBZR | 1.8 | 1.8
22 | U6 | TSSOP-8_4.4x3mm_Pitch0.65mm | 1 | 23LC1024-I/ST | 579-23LC1024-I/ST | 2.57 | 2.57
23 | U7,U8 | SOT-23-5 | 2 | 74AHC1G125 | 595-SN74AHC1G125DBVR | 0.41 | 0.82
24 | USB1 | microb_usb_top_mount | 1 | MICRO-B_USB | 538-47346-1001 | 0.73 | 0.73
25 | SW1,SW2 | SKRKAEE010 | 2 | SKRKAEE010 | 688-SKRKAE | 0.48 | 0.96
26 | P1 | Socket_Strip_Straight_1x02 | 1 | CONN_01X02 |  |  | 0
27 | P2 | Socket_Strip_Straight_1x03 | 1 | CONN_01X03 |  |  | 0 | NM
28 | P3 | Molex_PicoBlade_53261-0371 | 1 | CONN_01X03 | 538-53261-0371 | 0.9 | 0 | NM
29 | P4 | Socket_Strip_Angled_2x05 | 1 | CONN_02X05 | 571-5103308-1 | 0.74 | 0.74 | NM
 |  |  |  |  |  | parts total | 39.96
 | Manafacturing |  |  |  |  | placements | 68
 | Board Size: |  |  | per |  | unique parts | 29
 | 64x37mm | smartprototyping | $146/100 | 1.46
 |  |  | $1000/1000 | 1
 | Assembly | smallbatchassembly | quantity 100 | 10.74
 |  |  | quantity 1000 | 5.25
 | Others
 |  | Acrylic Case | 110990059 | 3 | https://www.seeedstudio.com/Bus-Pirate-v4-Acrylic-case-kit-v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
 |  | IDC ribbon cable | CAB-09556 | 4.95 | https://www.sparkfun.com/products/9556
 | total cost | 52.160000000000004

## Code that names these connections

File robot/teensy/usbhid_testfixture_app/usbhid_testfixture_app.ino (part):

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#define LED0_PIN 39
#define LED1_PIN 38

#define SPI_DOUT_PIN 11
#define SPI_DIN_PIN 12
#define SPI_SCLK_PIN 13
#define SPI_CS1_PIN 31
#define SPI_CS0_PIN 10

#define PWM_0_PIN 2
#define PWM_1_PIN 3
#define PWM_2_PIN 4
#define PWM_3_PIN 5
#define PWM_4_PIN 6
#define PWM_5_PIN 7
#define PWM_6_PIN 8
#define PWM_7_PIN 9

#define ADC_0_PIN 14
#define ADC_1_PIN 15
#define ADC_2_PIN 16
#define ADC_3_PIN 17
#define ADC_4_PIN 18
#define ADC_5_PIN 19
#define ADC_6_PIN 20
#define ADC_7_PIN 21

// DAC
#define DAC_MUX_SEL_A_PIN 24
#define DAC_MUX_SEL_B_PIN 25
#define DAC_MUX_SEL_C_PIN 26

#define DAC_MUX_EN_PIN 27

#define DAC_MUX_SEL_A_MASK 0x04
#define DAC_MUX_SEL_B_MASK 0x02
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}

void timer0_callback(void) {
  adc->startSingleRead(readPin0, ADC_0); // also: startSingleDifferential, analogSynchronizedRead, analogSynchronizedReadDifferential

  uint16_t val;

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  b_pin_value = ((channel & DAC_MUX_SEL_B_MASK) >> DAC_MUX_SEL_B_SHIFT);
  c_pin_value = ((channel & DAC_MUX_SEL_C_MASK) >> DAC_MUX_SEL_C_SHIFT);
 
  digitalWrite(DAC_MUX_SEL_A_PIN, a_pin_value);
  digitalWrite(DAC_MUX_SEL_B_PIN, b_pin_value);
  digitalWrite(DAC_MUX_SEL_C_PIN, c_pin_value);
}

void max335_enable_channel(uint8_t cs, uint8_t channel) {
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    max335_state_0 = temp_value;

    //Serial.println("max335_enable_channel B");
    digitalWrite(SPI_CS0_PIN, LOW);
    //Serial.println("max335_enable_channel C");
    SPI.transfer(temp_value);
    //Serial.println("max335_enable_channel D");
    digitalWrite(SPI_CS0_PIN, HIGH);
    //Serial.println("max335_enable_channel E");
  } else if (cs == USBHID_TESTFIXTURE_MAX335_CS_1) {
    temp_value = max335_state_1;
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    max335_state_1 = temp_value;

    //Serial.println("max335_enable_channel F");
    digitalWrite(SPI_CS1_PIN, LOW);
    //Serial.println("max335_enable_channel G");
    SPI.transfer(temp_value);
    //Serial.println("max335_enable_channel H");
    digitalWrite(SPI_CS1_PIN, HIGH);
    //Serial.println("max335_enable_channel I");
  } else {
    //Serial.println("max335_enable_channel J");
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    temp_value &= ~(1 << channel);
    max335_state_0 = temp_value;
    
    digitalWrite(SPI_CS0_PIN, LOW);
    SPI.transfer(temp_value);
    digitalWrite(SPI_CS0_PIN, HIGH);
  } else if (cs == USBHID_TESTFIXTURE_MAX335_CS_1) {
    temp_value = max335_state_1;
    temp_value &= ~(1 << channel);
    max335_state_1 = temp_value;
    
    digitalWrite(SPI_CS1_PIN, LOW);
    SPI.transfer(temp_value);
    digitalWrite(SPI_CS1_PIN, HIGH);
  } else {
    return;
  }
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void pwm_set_duty_value(uint8_t channel, uint16_t value) {
  switch (channel) {
    case TEENSY_PWM_0:
      analogWrite(PWM_0_PIN, value);
      break;

    case TEENSY_PWM_1:
      analogWrite(PWM_1_PIN, value);
      break;

    case TEENSY_PWM_2:
      analogWrite(PWM_2_PIN, value);
      break;

    case TEENSY_PWM_3:
      analogWrite(PWM_3_PIN, value);
      break;

    case TEENSY_PWM_4:
      analogWrite(PWM_4_PIN, value);
      break;
      
    default:
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}

void pwm_set_freq_value(uint8_t channel, uint32_t value) {
  analogWriteFrequency(PWM_0_PIN, value);
  analogWriteFrequency(PWM_1_PIN, value);
}

void dac_mux_set_channel(uint8_t channel) {
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}

void dac_mux_disable(void) {
  digitalWrite(DAC_MUX_EN_PIN, HIGH);
}

void dac_mux_enable(void) {
  digitalWrite(DAC_MUX_EN_PIN, LOW);
}

void pwm_enable_channel(uint8_t channel) {
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}

void dac_init(void) {
  pinMode(DAC_MUX_SEL_A_PIN, OUTPUT);
  pinMode(DAC_MUX_SEL_B_PIN, OUTPUT);
  pinMode(DAC_MUX_SEL_C_PIN, OUTPUT);

  pinMode(DAC_MUX_EN_PIN, OUTPUT);
}

void adc_test(void) {
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
  for (int i = 0; i < 100; i++) {
    uint16_t value;
    value = adc_get_value(ADC_0_PIN);
    
    //Serial.print("Value: ");
    Serial.print(value, DEC);
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}

void pwm0_pin_change(void) {
  pwm_pin_check(PWM_0_PIN, TEENSY_PWM_0);
}

void pwm1_pin_change(void) {
  pwm_pin_check(PWM_1_PIN, TEENSY_PWM_1);
}

void pwm2_pin_change(void) {
  pwm_pin_check(PWM_2_PIN, TEENSY_PWM_2);
}

void pwm3_pin_change(void) {
  pwm_pin_check(PWM_3_PIN, TEENSY_PWM_3);
}

void pwm4_pin_change(void) {
  pwm_pin_check(PWM_4_PIN, TEENSY_PWM_4);
}

void pwm_pin_mode_input(void) {
  pinMode(PWM_0_PIN, INPUT_PULLUP);
  pinMode(PWM_1_PIN, INPUT_PULLUP);
  pinMode(PWM_2_PIN, INPUT_PULLUP);
  pinMode(PWM_3_PIN, INPUT_PULLUP);
  pinMode(PWM_4_PIN, INPUT_PULLUP);
}

void pwm_pin_mode_output(void) {
  pinMode(PWM_0_PIN, OUTPUT);
  pinMode(PWM_1_PIN, OUTPUT);
  pinMode(PWM_2_PIN, OUTPUT);
  pinMode(PWM_3_PIN, OUTPUT);
  pinMode(PWM_4_PIN, OUTPUT);

  analogWrite(PWM_0_PIN, 2048);
  analogWrite(PWM_1_PIN, 2048);
  analogWrite(PWM_2_PIN, 2048);
  analogWrite(PWM_3_PIN, 2048);
  analogWrite(PWM_4_PIN, 2048);
}

void setup() {
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  analogWriteResolution(12);

  // enable SPI for MAX335 SPDT switches for ADC and PWM
  pinMode(SPI_CS1_PIN, OUTPUT);
  pinMode(SPI_CS0_PIN, OUTPUT);

  digitalWrite(SPI_CS1_PIN, HIGH);
  digitalWrite(SPI_CS0_PIN, HIGH);
  
  SPI.begin(); 

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  switch (channel) {
    case USBHID_SERIAL_CHANNEL_0:
      *channelTemp = USBHID_CHANNELS_FIO_0;
      *adcPin = ADC_0_PIN;
      break;

    case USBHID_SERIAL_CHANNEL_1:
      *channelTemp = USBHID_CHANNELS_FIO_1;
      *adcPin = ADC_1_PIN;
      break;

    case USBHID_SERIAL_CHANNEL_2:
      *channelTemp = USBHID_CHANNELS_FIO_2;
      *adcPin = ADC_2_PIN;
      break;

    case USBHID_SERIAL_CHANNEL_3:
      *channelTemp = USBHID_CHANNELS_FIO_3;
      *adcPin = ADC_3_PIN;
      break;

    case USBHID_SERIAL_CHANNEL_4:
      *channelTemp = USBHID_CHANNELS_FIO_4;
      *adcPin = ADC_4_PIN;
      break;

    case USBHID_SERIAL_CHANNEL_5:
      *channelTemp = USBHID_CHANNELS_FIO_5;
      *adcPin = ADC_5_PIN;
      break;

    case USBHID_SERIAL_CHANNEL_6:
      *channelTemp = USBHID_CHANNELS_FIO_6;
      *adcPin = ADC_6_PIN;
      break;

    case USBHID_SERIAL_CHANNEL_7:
      *channelTemp = USBHID_CHANNELS_FIO_7;
      *adcPin = ADC_7_PIN;
      break;

    default:
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}

void pwm_detach_interrupts(void) {
  detachInterrupt(PWM_0_PIN);
  detachInterrupt(PWM_1_PIN);
  detachInterrupt(PWM_2_PIN);
  detachInterrupt(PWM_3_PIN);
  detachInterrupt(PWM_4_PIN);
}

void pwm_attach_interrupt(int channel) {
  switch (channel) {
    case USBHID_CHANNELS_FIO_0:
      attachInterrupt(PWM_0_PIN, pwm0_pin_change, CHANGE);
      break;
      
    case USBHID_CHANNELS_FIO_1:
      attachInterrupt(PWM_1_PIN, pwm1_pin_change, CHANGE);
      break;

    case USBHID_CHANNELS_FIO_2:
      attachInterrupt(PWM_2_PIN, pwm2_pin_change, CHANGE);
      break;

    case USBHID_CHANNELS_FIO_3:
      attachInterrupt(PWM_3_PIN, pwm3_pin_change, CHANGE);
      break;

    case USBHID_CHANNELS_FIO_4:
      attachInterrupt(PWM_4_PIN, pwm4_pin_change, CHANGE);
      break;
  }
}
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